# Keil uVision project STM32_project.uvprojx, settings and files
target Target1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_H,USE_STDPERIPH_DRIVER
  c include: .\LIB\inc;.\System;.\USR;.\USR\my_gpio;.\USR\my_i2c
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USR
    ./USR/: main.c include.h Delay.c Delay.h SSD1306.c SSD1306.h font.c font.h Flash.c Flash.h my_snack.c my_snack.h Serial.c Serial.h MPU6050.c MPU6050.h MPU6050_Reg.h Time.c Time.h kalman.c kalman.h mahony_filter.c mahony_filter.h
    ./USR/my_gpio/: my_gpio.c my_gpio.h
    ./USR/my_i2c/: my_i2c.c my_i2c.h
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group LIB
    ./LIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_flash.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
    ./LIB/inc/: stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_i2c.h stm32f10x_flash.h stm32f10x_usart.h misc.h stm32f10x_tim.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_fsmc.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_wwdg.h
  group System
    ./System/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
